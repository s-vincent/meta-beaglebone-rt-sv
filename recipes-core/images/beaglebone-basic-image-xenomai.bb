include beaglebone-hwup-image-xenomai.bb

IMAGE_FEATURES += "ssh-server-dropbear"

